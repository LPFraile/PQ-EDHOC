## samples/zephyr_edhoc_block_client_pq/initiator_test_10/Kconfig
```kconfig
config BT_LONG_WQ_STACK_SIZE
	int "Long workqueue stack size"
	default 3000
source "Kconfig.zephyr"
```
